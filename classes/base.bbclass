BB_DEFAULT_TASK = "build"  

addtask build
addtask clean
